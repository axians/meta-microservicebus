inherit bundle

RAUC_BUNDLE_COMPATIBLE = "msb-rpi3-rauc"

RAUC_BUNDLE_SLOTS = "rootfs"
RAUC_SLOT_rootfs = "my-rootfs-recipe"

RAUC_KEY_FILE = "path/to/development-1.key.pem"
RAUC_CERT_FILE = "path/to/development-1.cert.pem"
