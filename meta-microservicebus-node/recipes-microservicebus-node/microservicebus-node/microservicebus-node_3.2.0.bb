do_patch_prepend () {
    QUILTRCPATH = d.getVar('STAGING_ETCDIR_NATIVE', expand=True)

    # remove already existing quiltrc
    try:
      os.unlink(f"{QUILTRCPATH}/quiltrc")
    except Exception:
      pass

    # Make our customized quiltrc the default one.
    WORKDIR = d.getVar('WORKDIR', expand=True)
    os.link(f"{WORKDIR}/quiltrc", f"{QUILTRCPATH}/quiltrc")
}

require microservicebus-node.inc

NPM_SHRINKWRAP := "${THISDIR}/${PN}/npm-shrinkwrap_${PV}.json"
# NPM_LOCKDOWN := "${THISDIR}/${PN}/lockdown_${PV}.json"

# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
#
# NOTE: multiple licenses have been detected; they have been separated with &
# in the LICENSE value for now since it is a reasonable assumption that all
# of the licenses apply. If instead there is a choice between the multiple
# licenses then you should change the value to separate the licenses with |
# instead of &. If there is any doubt, check the accompanying documentation
# to determine which situation is applicable.

LICENSE = "ISC & BSD-3-Clause & Unlicense & Apache-2.0 & MIT \
& BSD-2-Clause"
LIC_FILES_CHKSUM = " \
		file://node_modules/etag/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
		file://node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/media-typer/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
		file://node_modules/typedarray-to-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
		file://node_modules/istanbul-lib-coverage/LICENSE;md5=716b8ca15fee2be15af13159d0890c56 \
		file://node_modules/fast-deep-equal/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
		file://node_modules/sprintf-js/LICENSE;md5=ab40451de4e35c90f1b663b4fbd314a9 \
		file://node_modules/gensync/LICENSE;md5=4edef26a9728782f6e6a4ca612cfc1fb \
		file://node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
		file://node_modules/release-zalgo/LICENSE;md5=c2b237a3430a82027ddcc4c80ee5686c \
		file://node_modules/string.prototype.trimstart/LICENSE;md5=1e241a19d2d112b1db1a5c1c23216939 \
		file://node_modules/cookie/LICENSE;md5=bc85b43b6f963e8ab3f88e63628448ca \
		file://node_modules/html-escaper/LICENSE.txt;md5=7f76bc579cecca728c4f088789c787de \
		file://node_modules/foreground-child/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/picomatch/LICENSE;md5=abd0e25891525eb13d5a794f550a6ee4 \
		file://node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
		file://node_modules/he/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
		file://node_modules/is-extglob/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
		file://node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/sshpk/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
		file://node_modules/anymatch/LICENSE;md5=12cd52ddd05803f07238d49743e68e37 \
		file://node_modules/accepts/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
		file://node_modules/node-preload/LICENSE;md5=001f5a9ea84400e25b2192c4f379a825 \
		file://node_modules/has-symbols/LICENSE;md5=afee57a289508ed4df3456667778aaf6 \
		file://node_modules/@babel/core/node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/@babel/core/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
		file://node_modules/@babel/core/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/types/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helper-optimise-call-expression/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/traverse/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
		file://node_modules/@babel/traverse/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helper-simple-access/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helper-get-function-arity/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helper-replace-supers/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/highlight/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/code-frame/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helper-validator-identifier/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/generator/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helper-module-transforms/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helper-member-expression-to-functions/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helper-function-name/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helper-module-imports/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/template/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helpers/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/helper-split-export-declaration/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
		file://node_modules/@babel/parser/LICENSE;md5=3b324af8e79986f4a5621efa85dd1292 \
		file://node_modules/emoji-regex/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
		file://node_modules/serve-static/LICENSE;md5=27b1707520b14d0bc890f4e75cd387b0 \
		file://node_modules/is-nan/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
		file://node_modules/yargs-unparser/LICENSE;md5=f03c6ef2061d80f2064e17c8117e63a0 \
		file://node_modules/punycode/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
		file://node_modules/define-properties/LICENSE;md5=53ffc646fdb83e45279cfe7105e5157b \
		file://node_modules/istanbul-lib-source-maps/node_modules/source-map/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
		file://node_modules/istanbul-lib-source-maps/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
		file://node_modules/istanbul-lib-source-maps/LICENSE;md5=2c39380ca74c032242016476ea5f4e2c \
		file://node_modules/assert/LICENSE;md5=d7351a4fc8e956f1a68413490d5e655e \
		file://node_modules/is-string/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
		file://node_modules/es-to-primitive/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
		file://node_modules/yallist/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/toidentifier/LICENSE;md5=1a261071a044d02eb6f2bb47f51a3502 \
		file://node_modules/utils-merge/LICENSE;md5=1cf0906082187f374cb9a63c54eb782c \
		file://node_modules/source-map/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
		file://node_modules/asynckit/LICENSE;md5=177bc287fb9558bf3ea50b440c1c86ff \
		file://node_modules/content-type/LICENSE;md5=f4b767f006864f81a4901347fe4efdab \
		file://node_modules/is-regex/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
		file://node_modules/uuid/LICENSE.md;md5=353e680cdafd96bf30131cbb7b14a6e8 \
		file://node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
		file://node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
		file://node_modules/array-flatten/LICENSE;md5=44088ba57cb871a58add36ce51b8de08 \
		file://node_modules/duplexer2/LICENSE.md;md5=2ac3dfdce5a77f9cff9b5f70d216d17d \
		file://node_modules/js-tokens/LICENSE;md5=1d63bea73a26ffaf5e964ce74d3b83a5 \
		file://node_modules/tar/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/chokidar/LICENSE;md5=385493bcd68524333269db742d243165 \
		file://node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
		file://node_modules/yargs/LICENSE;md5=becfe5b407a6b8b768960384631232c9 \
		file://node_modules/minipass/LICENSE;md5=ff53df3ad94e5c618e230ab49ce310fa \
		file://node_modules/es6-error/LICENSE.md;md5=f4f6bdbcd0f2a80034d88e08f2479014 \
		file://node_modules/negotiator/LICENSE;md5=6417a862a5e35c17c904d9dda2cbd499 \
		file://node_modules/nyc/LICENSE.txt;md5=16ee39fb47fef70c573a1941c6ff2968 \
		file://node_modules/nyc/node_modules/emoji-regex/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
		file://node_modules/nyc/node_modules/yargs/LICENSE;md5=ec88e65c7bb01732069f3ad6b09ac90d \
		file://node_modules/nyc/node_modules/yargs-parser/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
		file://node_modules/nyc/node_modules/cliui/LICENSE.txt;md5=83623193d3051ca8068a89a455c699ca \
		file://node_modules/nyc/node_modules/color-convert/LICENSE;md5=9bdadfc9fbb3ab8d5a6d591bdbd52811 \
		file://node_modules/nyc/node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
		file://node_modules/write-file-atomic/LICENSE;md5=68705ba56afdf6710c9187ed9a9cdd03 \
		file://node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
		file://node_modules/json-schema-traverse/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
		file://node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
		file://node_modules/deep-eql/LICENSE;md5=4b2ce66eeab3484b3213e85ab6c0564d \
		file://node_modules/lodash.flattendeep/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
		file://node_modules/is-set/LICENSE;md5=c18cc44449ec61c93b216bf74e6c4fa4 \
		file://node_modules/har-schema/LICENSE;md5=bfa81591facc9224e4c7451c8dc12958 \
		file://node_modules/istanbul-lib-hook/LICENSE;md5=716b8ca15fee2be15af13159d0890c56 \
		file://node_modules/asn1/LICENSE;md5=5ce2f42143c298495637e28e40cd5462 \
		file://node_modules/is-typedarray/LICENSE.md;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
		file://node_modules/json5/LICENSE.md;md5=d80f2808a405d641840b50a06f80e93c \
		file://node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
		file://node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
		file://node_modules/bcrypt-pbkdf/LICENSE;md5=aaf6ebb9d1b815768d32661e72bdd761 \
		file://node_modules/mime/LICENSE;md5=8e8ea2ad138ce468f8570a0edbadea65 \
		file://node_modules/yargs-parser/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
		file://node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
		file://node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/string.prototype.trimend/LICENSE;md5=1e241a19d2d112b1db1a5c1c23216939 \
		file://node_modules/is-typed-array/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
		file://node_modules/istanbul-lib-report/LICENSE;md5=716b8ca15fee2be15af13159d0890c56 \
		file://node_modules/wide-align/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
		file://node_modules/extsprintf/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
		file://node_modules/fs-minipass/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/is-windows/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
		file://node_modules/esprima/LICENSE.BSD;md5=e3c825c932a984958bafbac21e21f984 \
		file://node_modules/path-to-regexp/LICENSE;md5=44088ba57cb871a58add36ce51b8de08 \
		file://node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/which-typed-array/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
		file://node_modules/glob/LICENSE;md5=c727d36f28f2762b1011dd483aa1a191 \
		file://node_modules/minizlib/LICENSE;md5=d8a0ca0c46bfa01db064fa836f550966 \
		file://node_modules/oauth-sign/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
		file://node_modules/ipaddr.js/LICENSE;md5=88f60a4b6e44cb849b5d907a7664c0ef \
		file://node_modules/dashdash/LICENSE.txt;md5=ebce61c1a0900d798daaf5853c69ce72 \
		file://node_modules/istanbul-lib-instrument/LICENSE;md5=716b8ca15fee2be15af13159d0890c56 \
		file://node_modules/superagent/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
		file://node_modules/superagent/LICENSE;md5=f6030206477cb73726a5c886539edb8b \
		file://node_modules/should-equal/LICENSE;md5=257f0a15e23399219e3de6c0c3d52bcb \
		file://node_modules/object-is/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
		file://node_modules/y18n/LICENSE;md5=55e5f88040679148136545002139a8b1 \
		file://node_modules/istanbul-reports/LICENSE;md5=716b8ca15fee2be15af13159d0890c56 \
		file://node_modules/ansi-colors/LICENSE;md5=442b5b961878bc805832d1d24572f62d \
		file://node_modules/is-negative-zero/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
		file://node_modules/diff/LICENSE;md5=e6f0309f3f9919cd96cc45a4d4859c54 \
		file://node_modules/verror/LICENSE;md5=04fce49dd88d841ceb36616ab9789ce0 \
		file://node_modules/request/node_modules/uuid/LICENSE.md;md5=c9420736e23afb538ba5fbe44197f0b4 \
		file://node_modules/request/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
		file://node_modules/type-is/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
		file://node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
		file://node_modules/http-signature/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
		file://node_modules/promise.allsettled/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
		file://node_modules/body-parser/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
		file://node_modules/body-parser/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
		file://node_modules/fill-range/LICENSE;md5=0f64900f8f30e53054962c9f1fc3205b \
		file://node_modules/es-abstract/LICENSE;md5=53ffc646fdb83e45279cfe7105e5157b \
		file://node_modules/glob-parent/LICENSE;md5=a3d42bb676c62db87cbf7b04d98da83e \
		file://node_modules/@types/color-name/LICENSE;md5=27e94c0280987ab296b0b8dd02ab9fe5 \
		file://node_modules/cliui/LICENSE.txt;md5=83623193d3051ca8068a89a455c699ca \
		file://node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
		file://node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739 \
		file://node_modules/chownr/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
		file://node_modules/jsprim/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
		file://node_modules/cookiejar/LICENSE;md5=dd627a90bb622a86c4b81863f55ae23d \
		file://node_modules/package-hash/LICENSE;md5=9b7c9c0f77f387fcc0027b4b35aeca6f \
		file://node_modules/ajv/LICENSE;md5=4973982316cdc12e988b814af2813df7 \
		file://node_modules/iterate-iterator/LICENSE;md5=0eb2c73daa0ecf037cbdf3d0bb0c98d5 \
		file://node_modules/color-convert/LICENSE;md5=9bdadfc9fbb3ab8d5a6d591bdbd52811 \
		file://node_modules/json-stringify-safe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/is-generator-function/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
		file://node_modules/browser-stdout/LICENSE;md5=3a82ca6497b86652ecafd7a5f256ff9b \
		file://node_modules/isstream/LICENSE.md;md5=1798150b9d70250c42b55b3530e6af2b \
		file://node_modules/es6-object-assign/LICENSE;md5=9b198a8be07bc68f5ff95ed2c444832e \
		file://node_modules/is-date-object/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
		file://node_modules/jsesc/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
		file://node_modules/chai/LICENSE;md5=576cc2707afcfda57920f5a59644c39f \
		file://node_modules/check-error/LICENSE;md5=4b2ce66eeab3484b3213e85ab6c0564d \
		file://node_modules/fresh/LICENSE;md5=373c2cf0978b37e434394a43b4cbbdb4 \
		file://node_modules/send/LICENSE;md5=df2b0938eba0709b77ac937e2d552b7a \
		file://node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
		file://node_modules/har-validator/LICENSE;md5=6f7daec5e5143ffeb21745646b425ab2 \
		file://node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
		file://node_modules/object.assign/node_modules/es-abstract/LICENSE;md5=53ffc646fdb83e45279cfe7105e5157b \
		file://node_modules/object.assign/LICENSE;md5=2b439ca9e99134dee172a7cc6d989174 \
		file://node_modules/merge-descriptors/LICENSE;md5=aaf57ba8c5c9bf256fea7e943991a81a \
		file://node_modules/object-inspect/LICENSE;md5=288162f1d1bfa064f127f2b42d2a656f \
		file://node_modules/require-reload/LICENSE;md5=9862e3aecc2338bb6a1af4d73cc7a1e7 \
		file://node_modules/get-caller-file/LICENSE.md;md5=d21aa422a43e9693d50143d612b58967 \
		file://node_modules/getpass/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
		file://node_modules/methods/LICENSE;md5=c16a7dd9f946172f07086576d135d9d3 \
		file://node_modules/process-on-spawn/LICENSE;md5=001f5a9ea84400e25b2192c4f379a825 \
		file://node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
		file://node_modules/which/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/test-exclude/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
		file://node_modules/pathval/LICENSE;md5=b8954a1386acffa30d8daf0ca02c02e3 \
		file://node_modules/workerpool/LICENSE;md5=6c4db32a2fa8717faffa1d4f10136f47 \
		file://node_modules/object-keys/LICENSE;md5=0026e638d7d5c5f2768864ce0074f8ad \
		file://node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
		file://node_modules/should-type/LICENSE;md5=b9d99d98c0703a6b8791ceb941a485ee \
		file://node_modules/argparse/LICENSE;md5=a2f2590d8d82b0fa2b3e2fc5c69d2b81 \
		file://node_modules/vary/LICENSE;md5=13babc4f212ce635d68da544339c962b \
		file://node_modules/is-arguments/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
		file://node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
		file://node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
		file://node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
		file://node_modules/serialize-javascript/LICENSE;md5=88ca0f627a04462a0ac7effbc69ae1c7 \
		file://node_modules/psl/LICENSE;md5=2425d288296fae32e27553694ff40294 \
		file://node_modules/is-glob/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
		file://node_modules/proxy-addr/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
		file://node_modules/is-map/LICENSE;md5=c18cc44449ec61c93b216bf74e6c4fa4 \
		file://node_modules/graceful-readlink/LICENSE;md5=b0270ddb7ee6643eee76e80113234806 \
		file://node_modules/convert-source-map/LICENSE;md5=bf595075ff556bc46c43e08f142fa4f5 \
		file://node_modules/spawn-wrap/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/fsevents/LICENSE;md5=76d77bb5bb62ad250453f947253ea01c \
		file://node_modules/rc/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
		file://node_modules/rc/LICENSE.BSD;md5=e7a2a325a0069e82aff675bbf74464a0 \
		file://node_modules/rc/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
		file://node_modules/finalhandler/LICENSE;md5=b506956e5cbfbe0d04f8a5c40107ec89 \
		file://node_modules/aws4/LICENSE;md5=ff6f181928a91d8631d565516b4db3cb \
		file://node_modules/commander/LICENSE;md5=25851d4d10d6611a12d5571dab945a00 \
		file://node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
		file://node_modules/foreach/LICENSE;md5=b2225091caf5effa363ef7016fa2b0ba \
		file://node_modules/colors/LICENSE;md5=441ee46669f9365ff2492e9b555c8ee7 \
		file://node_modules/network/node_modules/async/LICENSE;md5=dc113e0fc4029c29942399ad22425402 \
		file://node_modules/braces/LICENSE;md5=ccdc0959f67943eb090f7e7c299621af \
		file://node_modules/to-regex-range/LICENSE;md5=b561e0a423bedc9d9ca9c8c67d40abb9 \
		file://node_modules/forwarded/LICENSE;md5=13babc4f212ce635d68da544339c962b \
		file://node_modules/aws-sign2/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
		file://node_modules/tunnel-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
		file://node_modules/require-main-filename/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
		file://node_modules/tweetnacl/LICENSE;md5=911690f51af322440237a253d695d19f \
		file://node_modules/tough-cookie/LICENSE;md5=7189377a5215f1211b70cf2b9754841e \
		file://node_modules/has/LICENSE-MIT;md5=d000afc3c9ff3501a5610197db76a246 \
		file://node_modules/js-yaml/LICENSE;md5=effd621a9bf5d72d6a7e6ef819bf3afb \
		file://node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
		file://node_modules/formidable/LICENSE;md5=d190db72ba5a319d036a660bc442f16c \
		file://node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
		file://node_modules/uri-js/LICENSE;md5=3b55dad4a98748003b5b423477713da1 \
		file://node_modules/fromentries/LICENSE;md5=fb42e5aa12bb9e365d38b4b5691d6984 \
		file://node_modules/destroy/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
		file://node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/array.prototype.map/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
		file://node_modules/es-array-method-boxes-properly/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
		file://node_modules/ecc-jsbn/lib/LICENSE-jsbn;md5=32052d48bacabd1c02e56c6889082a27 \
		file://node_modules/ecc-jsbn/LICENSE;md5=0d289b6d63cbcc18e4b2af9a5bd28b54 \
		file://node_modules/iterate-value/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
		file://node_modules/signal-exit/LICENSE.txt;md5=e29e20260a1c78dba16a233048565cde \
		file://node_modules/set-blocking/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
		file://node_modules/should-util/LICENSE;md5=dc1de4fd31f0ead856f3e4a3d0e4bb0d \
		file://node_modules/deep-extend/LICENSE;md5=827bb5781213ff1e9d2fe309bbfc0115 \
		file://node_modules/lodash/LICENSE;md5=8e2fca844c70b3833d7228885447c026 \
		file://node_modules/ini/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/is-number/LICENSE;md5=0f64900f8f30e53054962c9f1fc3205b \
		file://node_modules/parseurl/LICENSE;md5=e7842ed4f188e53e53c3e8d9c4807e89 \
		file://node_modules/util/LICENSE;md5=d7351a4fc8e956f1a68413490d5e655e \
		file://node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
		file://node_modules/readdirp/LICENSE;md5=d982124c58b759403329f9c0906aae7a \
		file://node_modules/fast-json-stable-stringify/LICENSE;md5=febe55307df96f60ad763842f5a8ca6f \
		file://node_modules/which-module/LICENSE;md5=42624e59bd3dabedcca59e1b54e3af50 \
		file://node_modules/available-typed-arrays/LICENSE;md5=838b75dc6028daf3e04e57871b7ad3ed \
		file://node_modules/should-type-adaptors/LICENSE;md5=dc1de4fd31f0ead856f3e4a3d0e4bb0d \
		file://node_modules/get-package-type/LICENSE;md5=0dea536beaa7ef82467edd8f2131edd5 \
		file://node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
		file://node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
		file://node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
		file://node_modules/content-disposition/LICENSE;md5=13babc4f212ce635d68da544339c962b \
		file://node_modules/forever-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
		file://node_modules/safer-buffer/LICENSE;md5=3baebc2a17b8f5bff04882cd0dc0f76e \
		file://node_modules/function-bind/LICENSE;md5=e7417c1a8ad83f88bcac21ad440d48b2 \
		file://node_modules/type-detect/LICENSE;md5=4b2ce66eeab3484b3213e85ab6c0564d \
		file://node_modules/commondir/LICENSE;md5=31f6d70a3b756797901b2aff55cc7d7a \
		file://node_modules/caseless/LICENSE;md5=e9dadf023ba6ebd98e3e0acb6e2470e3 \
		file://node_modules/is-callable/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
		file://node_modules/mocha/node_modules/object.assign/LICENSE;md5=2b439ca9e99134dee172a7cc6d989174 \
		file://node_modules/mocha/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
		file://node_modules/mocha/LICENSE;md5=09e8b42afe53bbca2ce608241d874765 \
		file://node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
		file://node_modules/require-directory/LICENSE;md5=903997d26b12b72b43aa60018387bb90 \
		file://node_modules/cross-spawn/LICENSE;md5=6046ffd2c9edcd9052bb4dd794d12f95 \
		file://node_modules/raw-body/LICENSE;md5=c970d30155ebbdb1903e6de8c0666e18 \
		file://node_modules/isexe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/mkdirp/LICENSE;md5=f653359cc2be3ff55aa601d58d84c808 \
		file://node_modules/@istanbuljs/load-nyc-config/LICENSE;md5=5ef874cb7b66ddc31655c77320518833 \
		file://node_modules/@istanbuljs/schema/LICENSE;md5=001f5a9ea84400e25b2192c4f379a825 \
		file://node_modules/get-func-name/LICENSE;md5=4b2ce66eeab3484b3213e85ab6c0564d \
		file://node_modules/path-parse/LICENSE;md5=4b940f9668dfcb796d2cb98ad94692df \
		file://node_modules/istanbul-lib-processinfo/node_modules/uuid/LICENSE.md;md5=c9420736e23afb538ba5fbe44197f0b4 \
		file://node_modules/istanbul-lib-processinfo/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
		file://node_modules/es-get-iterator/node_modules/isarray/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
		file://node_modules/es-get-iterator/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
		file://node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
		file://node_modules/express/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
		file://node_modules/express/LICENSE;md5=5513c00a5c36cd361da863dd9aa8875d \
		file://node_modules/archy/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
		file://node_modules/normalize-path/LICENSE;md5=ccdc0959f67943eb090f7e7c299621af \
		file://node_modules/should-format/LICENSE;md5=b9d99d98c0703a6b8791ceb941a485ee \
		file://node_modules/is-symbol/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
		file://node_modules/error-ex/LICENSE;md5=e67c75e89656b80fd99cb7d30fb43102 \
		file://node_modules/supertest/LICENSE;md5=eacbaae25552d53aba44661c68b770d7 \
		file://node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
		file://node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
		file://node_modules/should/LICENSE;md5=f623b23bfa4e6df5d05de8639b8fc05b \
		file://node_modules/flat/LICENSE;md5=13aa15a115948e34248388ca8956ea4d \
		file://node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
		file://node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
		file://node_modules/wmic/node_modules/async/LICENSE;md5=73f63c1fa4541b2f2f34d77140ebe89d \
		file://node_modules/async/LICENSE;md5=73f63c1fa4541b2f2f34d77140ebe89d \
		file://node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
		file://node_modules/resolve/LICENSE;md5=baa47288b5bd3e657a01886ce3dd0cb6 \
		file://node_modules/is-arrayish/LICENSE;md5=e67c75e89656b80fd99cb7d30fb43102"

SRC_URI_append = " file://0001-nodejs-v12-runtime-compat.patch;patchdir=${WORKDIR}/npmpkg"
SRC_URI_append = " file://quiltrc"

# Must be set after inherit npm since that itself sets S
S = "${WORKDIR}/npmpkg"

LICENSE_${PN}-app-module-path = "BSD-2-Clause"
LICENSE_${PN}-async = "MIT"
LICENSE_${PN}-colors = "MIT"
LICENSE_${PN}-compare-version = "MIT"
LICENSE_${PN}-minimist = "MIT"
LICENSE_${PN}-network-async = "MIT"
LICENSE_${PN}-network-commander-graceful-readlink = "MIT"
LICENSE_${PN}-network-commander = "MIT"
LICENSE_${PN}-network-needle-debug-ms = "MIT"
LICENSE_${PN}-network-needle-debug = "MIT"
LICENSE_${PN}-network-needle-iconv-lite-safer-buffer = "MIT"
LICENSE_${PN}-network-needle-iconv-lite = "MIT"
LICENSE_${PN}-network-needle = "MIT"
LICENSE_${PN}-network-wmic-async = "MIT"
LICENSE_${PN}-network-wmic-iconv-lite = "MIT"
LICENSE_${PN}-network-wmic = "ISC"
LICENSE_${PN}-network = "MIT"
LICENSE_${PN}-package-json-got-create-error-class-capture-stack-trace = "MIT"
LICENSE_${PN}-package-json-got-create-error-class = "MIT"
LICENSE_${PN}-package-json-got-duplexer2-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-package-json-got-duplexer2-readable-stream-inherits = "ISC"
LICENSE_${PN}-package-json-got-duplexer2-readable-stream-isarray = "MIT"
LICENSE_${PN}-package-json-got-duplexer2-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-package-json-got-duplexer2-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-package-json-got-duplexer2-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-package-json-got-duplexer2-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-package-json-got-duplexer2-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-package-json-got-duplexer2-readable-stream = "MIT"
LICENSE_${PN}-package-json-got-duplexer2 = "BSD-3-Clause"
LICENSE_${PN}-package-json-got-is-redirect = "MIT"
LICENSE_${PN}-package-json-got-is-retry-allowed = "MIT"
LICENSE_${PN}-package-json-got-is-stream = "MIT"
LICENSE_${PN}-package-json-got-lowercase-keys = "MIT"
LICENSE_${PN}-package-json-got-node-status-codes = "MIT"
LICENSE_${PN}-package-json-got-object-assign = "MIT"
LICENSE_${PN}-package-json-got-parse-json-error-ex-is-arrayish = "MIT"
LICENSE_${PN}-package-json-got-parse-json-error-ex = "MIT"
LICENSE_${PN}-package-json-got-parse-json = "MIT"
LICENSE_${PN}-package-json-got-pinkie-promise-pinkie = "MIT"
LICENSE_${PN}-package-json-got-pinkie-promise = "MIT"
LICENSE_${PN}-package-json-got-read-all-stream-readable-stream = "MIT"
LICENSE_${PN}-package-json-got-read-all-stream = "MIT"
LICENSE_${PN}-package-json-got-readable-stream = "MIT"
LICENSE_${PN}-package-json-got-timed-out = "MIT"
LICENSE_${PN}-package-json-got-unzip-response = "MIT"
LICENSE_${PN}-package-json-got-url-parse-lax-prepend-http = "MIT"
LICENSE_${PN}-package-json-got-url-parse-lax = "MIT"
LICENSE_${PN}-package-json-got = "MIT"
LICENSE_${PN}-package-json-rc-deep-extend = "MIT"
LICENSE_${PN}-package-json-rc-ini = "ISC"
LICENSE_${PN}-package-json-rc-minimist = "MIT"
LICENSE_${PN}-package-json-rc-strip-json-comments = "MIT"
LICENSE_${PN}-package-json-rc = "MIT"
LICENSE_${PN}-package-json-registry-url-rc = "MIT"
LICENSE_${PN}-package-json-registry-url = "MIT"
LICENSE_${PN}-package-json = "MIT"
LICENSE_${PN}-request-aws-sign2 = "Apache-2.0"
LICENSE_${PN}-request-aws4 = "MIT"
LICENSE_${PN}-request-caseless = "Apache-2.0"
LICENSE_${PN}-request-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-request-combined-stream = "MIT"
LICENSE_${PN}-request-extend = "MIT"
LICENSE_${PN}-request-forever-agent = "Apache-2.0"
LICENSE_${PN}-request-form-data-asynckit = "MIT"
LICENSE_${PN}-request-form-data-combined-stream = "MIT"
LICENSE_${PN}-request-form-data-mime-types-mime-db = "MIT"
LICENSE_${PN}-request-form-data-mime-types = "MIT"
LICENSE_${PN}-request-form-data = "MIT"
LICENSE_${PN}-request-har-validator-ajv-fast-deep-equal = "MIT"
LICENSE_${PN}-request-har-validator-ajv-fast-json-stable-stringify = "MIT"
LICENSE_${PN}-request-har-validator-ajv-json-schema-traverse = "MIT"
LICENSE_${PN}-request-har-validator-ajv-uri-js-punycode = "MIT"
LICENSE_${PN}-request-har-validator-ajv-uri-js = "BSD-2-Clause"
LICENSE_${PN}-request-har-validator-ajv = "MIT"
LICENSE_${PN}-request-har-validator-har-schema = "ISC"
LICENSE_${PN}-request-har-validator = "MIT"
LICENSE_${PN}-request-http-signature-assert-plus = "MIT"
LICENSE_${PN}-request-http-signature-jsprim-assert-plus = "MIT"
LICENSE_${PN}-request-http-signature-jsprim-extsprintf = "MIT"
LICENSE_${PN}-request-http-signature-jsprim-json-schema = "BSD 3-Clause"
LICENSE_${PN}-request-http-signature-jsprim-verror-core-util-is = "MIT"
LICENSE_${PN}-request-http-signature-jsprim-verror-extsprintf = "MIT"
LICENSE_${PN}-request-http-signature-jsprim-verror = "MIT"
LICENSE_${PN}-request-http-signature-jsprim = "MIT"
LICENSE_${PN}-request-http-signature-sshpk-asn1-safer-buffer = "MIT"
LICENSE_${PN}-request-http-signature-sshpk-asn1 = "MIT"
LICENSE_${PN}-request-http-signature-sshpk-bcrypt-pbkdf-tweetnacl = "Unlicense"
LICENSE_${PN}-request-http-signature-sshpk-bcrypt-pbkdf = "BSD-3-Clause"
LICENSE_${PN}-request-http-signature-sshpk-dashdash = "MIT"
LICENSE_${PN}-request-http-signature-sshpk-ecc-jsbn-safer-buffer = "MIT"
LICENSE_${PN}-request-http-signature-sshpk-ecc-jsbn = "MIT"
LICENSE_${PN}-request-http-signature-sshpk-getpass = "MIT"
LICENSE_${PN}-request-http-signature-sshpk-jsbn = "MIT"
LICENSE_${PN}-request-http-signature-sshpk-safer-buffer = "MIT"
LICENSE_${PN}-request-http-signature-sshpk-tweetnacl = "Unlicense"
LICENSE_${PN}-request-http-signature-sshpk = "MIT"
LICENSE_${PN}-request-http-signature = "MIT"
LICENSE_${PN}-request-is-typedarray = "MIT"
LICENSE_${PN}-request-isstream = "MIT"
LICENSE_${PN}-request-json-stringify-safe = "ISC"
LICENSE_${PN}-request-mime-types = "MIT"
LICENSE_${PN}-request-oauth-sign = "Apache-2.0"
LICENSE_${PN}-request-performance-now = "MIT"
LICENSE_${PN}-request-qs = "BSD-3-Clause"
LICENSE_${PN}-request-safe-buffer = "MIT"
LICENSE_${PN}-request-tough-cookie-psl = "MIT"
LICENSE_${PN}-request-tough-cookie-punycode = "MIT"
LICENSE_${PN}-request-tough-cookie = "BSD-3-Clause"
LICENSE_${PN}-request-tunnel-agent-safe-buffer = "MIT"
LICENSE_${PN}-request-tunnel-agent = "Apache-2.0"
LICENSE_${PN}-request-uuid = "MIT"
LICENSE_${PN}-request = "Apache-2.0"
LICENSE_${PN}-require-reload = "MIT"
LICENSE_${PN}-tar-chownr = "ISC"
LICENSE_${PN}-tar-fs-minipass-minipass-yallist = "ISC"
LICENSE_${PN}-tar-fs-minipass-minipass = "ISC"
LICENSE_${PN}-tar-fs-minipass = "ISC"
LICENSE_${PN}-tar-minizlib = "MIT"
LICENSE_${PN}-tar-mkdirp = "MIT"
LICENSE_${PN}-tar = "ISC"
LICENSE_${PN}-uuid = "MIT"
LICENSE_${PN} = "MIT"
