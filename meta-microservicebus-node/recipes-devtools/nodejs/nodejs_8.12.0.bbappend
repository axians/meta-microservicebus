FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://0002-Bugfix-ipfamily-bitwise-operator.patch "
