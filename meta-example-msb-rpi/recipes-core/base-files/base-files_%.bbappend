FILESEXTRAPATHS_prepend := "${THISDIR}/base-files:"

SRC_URI_append = " \
  file://fstab \
  "
